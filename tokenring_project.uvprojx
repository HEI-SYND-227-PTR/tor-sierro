# Keil uVision project tokenring_project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::..\..\Program Files (x86)\ARM_Compiler_5.06u7)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: tokenring_project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\RTE\uGFX_library;.\
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  link misc: --keep=os_cb_sections
  group Source Group 1
    ./: main.c lcd.c touch.c chat_sender.c chat_receiver.c time_sender.c time_receiver.c mac_sender.c mac_receiver.c phy_receiver.c phy_sender.c debug.c main.h audio.c Audio_746G_Discovery.c
  group studio
    ./: gui.c resources_manager.c
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, Hesso pack:Extension Board:Buttons 1.0.0, Hesso pack:Extension Board:Keyboard 1.1.1, Hesso pack:Extension Board:LEDs 1.0.0, Hesso pack:Extension Board:UART 1.0.0, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0, CMSIS Driver:I2C 1.9.0, CMSIS Driver:SAI 1.5.0, Device:STM32Cube Framework:Classic 1.2.7, Device:STM32Cube HAL:Common 1.2.7, Device:STM32Cube HAL:Cortex 1.2.7, Device:STM32Cube HAL:DMA 1.2.7, Device:STM32Cube HAL:GPIO 1.2.7, Device:STM32Cube HAL:PWR 1.2.7, Device:STM32Cube HAL:RCC 1.2.7, Device:STM32Cube HAL:SDRAM 1.2.7, Device:STM32Cube HAL:SPI 1.2.7, Device:STM32Cube HAL:UART 1.2.7, Device:Startup 1.2.4, uGFX library:uGFX library 2.0.0
